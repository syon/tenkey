# Repository syon/tenkey

## KiCad design tenkey.kicad_pcb

Board: 2 copper layers, 78.0 x 147.0 mm, 48 parts (0 on the bottom side), 33 nets.

Parts:
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21: D; D3_TH
Ref**: Val**; HOLE
Ref**#2, Ref**#3, Ref**#4: Val**; HOLE
SW1, SW2, SW3, SW4, SW5, SW6, SW7, SW8, SW9, SW10, SW11, SW12, SW13, SW14, SW15, SW16, SW17, SW18: KEY_SWITCH; CherryMX_Choc_Hotswap
SW19, SW20: KEY_SWITCH; MXOnly-2U-Hotswap-ReversedStabilizers
SW21: KEY_SWITCH; MXOnly-1U-Hotswap
SW22: RESET_SWITCH; ResetSW
U1: ProMicro; ProMicro_v2_1side

Connections:
GND: SW22.2, U1.3, U1.4, U1.23
unnamed: D1.2, SW1.2
unnamed: D2.2, SW2.2
unnamed: D3.2, SW3.2
unnamed: D4.2, SW4.2
unnamed: D5.2, SW5.2
unnamed: D6.2, SW6.2
unnamed: D7.2, SW7.2
unnamed: D8.2, SW8.2
unnamed: D9.2, SW9.2
unnamed: D10.2, SW10.2
unnamed: D11.2, SW11.2
unnamed: D12.2, SW12.2
unnamed: D13.2, SW13.2
unnamed: D14.2, SW14.2
unnamed: D15.2, SW15.2
unnamed: D16.2, SW16.2
unnamed: D17.2, SW17.2
unnamed: D18.2, SW18.2
unnamed: D19.2, SW19.2
unnamed: D20.2, SW20.2
unnamed: D21.2, SW21.2
col0: SW1.1, SW5.1, SW9.1, SW13.1, SW16.1, SW20.1, U1.20
col1: SW2.1, SW6.1, SW10.1, SW14.1, SW17.1, U1.19
col2: SW3.1, SW7.1, SW11.1, SW15.1, SW18.1, SW21.1, U1.18
col3: SW4.1, SW8.1, SW12.1, SW19.1, U1.17
reset: SW22.1, U1.22
row0: D1.1, D2.1, D3.1, D4.1, U1.7
row1: D5.1, D6.1, D7.1, D8.1, U1.8
row2: D9.1, D10.1, D11.1, D12.1, U1.9
row3: D13.1, D14.1, D15.1, U1.10
row4: D16.1, D17.1, D18.1, D19.1, U1.11
row5: D20.1, D21.1, U1.12

## Commit log

2019-06-16 :seedling: First commit
2019-06-22 :anchor: QMK Firmware settings
